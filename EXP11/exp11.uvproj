# Keil uVision project exp11.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: exp11
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: EXP11.C EXP12.C EXP13.c
